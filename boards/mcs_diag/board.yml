## boards/mcs_diag/board.yml
```yaml
board:
  name: mcs_diag
  full_name: MCS Diag
  vendor: st
  socs:
    - name: stm32f446xx
```
